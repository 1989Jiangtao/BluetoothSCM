# Keil uVision project BluetoothLED.uvproj, settings and files
target BluetoothLED (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: BluetoothLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src
  group Main
    ../src/: main.c OLED.c DS18b20.c
